# IAR project project-end-device.ewp, settings and files
configuration eli_modem_end_device_stm8l151g6 (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0xa0
  General.GenHeapSize: 0x80
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L15X_MD; __MCU_8051; MODEM_FOR_END_DEVICE; xMODEM_FOR_GATEWAY
  ICCSTM8.CCIncludePath2: ..; ..\..\src; ..\..\src\apps; ..\..\src\components; ..\..\src\components\bal; ..\..\src\components\haddock-os; ..\..\src\components\lib_util; ..\..\src\components\easylinkin; ..\..\src\components\easylinkin\lpwan_mac; ..\..\src\components\easylinkin\radio; ..\..\src\components\mcal; ..\..\src\components\mcal\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group apps
    ../../src/apps/: app_config.c app_config.h app_hostif.c app_hostif.h
  group components/bal
    ../../src/components/bal/: hal_board_cfg.h
  group components/bal/rf
    ../../src/components/bal/rf/common/: rf_config.h
  group components/bal/rf/common
    ../../src/components/bal/rf/common/: rf_manager.c rf_manager.h rf_type.h
  group components/bal/rf/sx1278
    ../../src/components/bal/rf/sx1278/: rf_sx1278.c sx1276_cfg.h sx1276_config.c sx1276_config.h sx1276_hal.c sx1276_hal.h sx1276_lora.h sx1276_spi.c sx1276_spi.h
  group components/bal/sleep
    ../../src/components/bal/sleep/: sleep.c sleep.h
  group components/bal/systick
    ../../src/components/bal/systick/: hal_systick.c hal_systick.h
  group components/bal/uart
    ../../src/components/bal/uart/: hal_uart.c hal_uart.h
  group components/easylinkin/lpwan_mac
    ../../src/components/easylinkin/lpwan_mac/: lpwan_config.c lpwan_config.h lpwan_types.h lpwan_utils.c lpwan_utils.h
  group components/easylinkin/lpwan_mac/end_device
    ../../src/components/easylinkin/lpwan_mac/end_device/: config_end_device.h mac_engine.c mac_engine.h mac_engine_config.h
  group components/easylinkin/lpwan_mac/frame_defs
    ../../src/components/easylinkin/lpwan_mac/frame_defs/: common_defs.h device_join_request.h device_uplink_ack.h device_uplink_cmd.h device_uplink_common.h device_uplink_data_request.h device_uplink_msg.h frame_defs.h frame_header.h gw_beacon.h gw_downlink_ack.h gw_downlink_cmd.h gw_downlink_common.h gw_downlink_msg.h gw_join_response.h
  group components/easylinkin/lpwan_mac/gateway
    ../../src/components/easylinkin/lpwan_mac/gateway/: config_gateway.h mac_engine.c mac_engine.h
  group components/easylinkin/lpwan_mac/protocol_utils
    ../../src/components/easylinkin/lpwan_mac/protocol_utils/: construct_de_uplink_msg.c construct_de_uplink_msg.h construct_frame_hdr.c construct_frame_hdr.h construct_gw_beacon.c construct_gw_beacon.h parse_beacon.c parse_beacon.h parse_device_uplink_msg.c parse_device_uplink_msg.h parse_frame_hdr.c parse_frame_hdr.h parse_gw_join_response.c parse_gw_join_response.h parsed_common_defs.h
  group components/easylinkin/radio
    ../../src/components/easylinkin/radio/: lpwan_radio.c lpwan_radio.h radio_config.h
  group components/haddock-os
    ../../src/components/haddock-os/: haddock_types.h hdk_user_config.h
  group components/haddock-os/hal
    ../../src/components/haddock-os/hal/: hal_config.h hal_mcu.h
  group components/haddock-os/hal/stm32f103
    ../../src/components/haddock-os/hal/stm32f103/: hal_config_stm32f103.h hal_init.c hal_sleep.c hal_stm32f103.h
  group components/haddock-os/hal/stm8l151
    ../../src/components/haddock-os/hal/stm8l151/: hal_config_stm8l151.h hal_init.c hal_sleep.c hal_stm8l151.h
  group components/haddock-os/kernel
    ../../src/components/haddock-os/kernel/: hdk_memory.c hdk_memory.h ipc.c ipc.h kernel_config.c kernel_config.h kernel_main.c power_manager.c power_manager.h process.c process.h scheduler.c scheduler.h sys_signal_defs.h timer.c timer.h
  group components/haddock-os/lib
    ../../src/components/haddock-os/lib/: assert.h hdk_utilities.c hdk_utilities.h linked_list.h mem_pool.c mem_pool.h ringbuffer.c ringbuffer.h
  group components/haddock-os/os_user_processes
    ../../src/components/haddock-os/os_user_processes/: os_user_processes.h
  group components/haddock-os/os_user_processes/easylinkin_modem
    ../../src/components/haddock-os/os_user_processes/easylinkin_modem/: easylinkin_modem_process.c easylinkin_modem_process.h process_hostif.c process_hostif.h
  group components/haddock-os/os_user_processes/example_user_name
    ../../src/components/haddock-os/os_user_processes/example_user_name/: main_example_user.c
  group components/lib_util
    ../../src/components/lib_util/: common_lib_cfg.h
  group components/lib_util/checksum
    ../../src/components/lib_util/checksum/: checksum.c checksum.h
  group components/lib_util/crc
    ../../src/components/lib_util/crc/: crc.c crc.h
  group components/mcal
    ../../src/components/mcal/: stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group components/mcal/STM8L15x_StdPeriph_Driver/inc
    ../../src/components/mcal/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group components/mcal/STM8L15x_StdPeriph_Driver/src
    ../../src/components/mcal/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group components/notes/code_samples
    ../../src/components/notes/code_samples/: c_template.txt h_template.txt
