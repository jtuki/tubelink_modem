# Keil uVision project modem_end_node.uvprojx, settings and files
target stm32l051k8 (ARM-ADS)
  device: STM32L051K8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: modem_end_node +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: xLPWAN_DEBUG_ONLY_TRACK_BEACON, STM32L051xx,USE_HAL_DRIVER, __ARM_CORTEX_M, MODEM_FOR_END_DEVICE,
  c misc: --C99
  c include: ..\..\src\components\;..\..\src\components\mcal\cmsis\Include;..\..\src\components\mcal\cmsis\Device\ST\STM32L0xx\Include;..\..\src;..\..\src\apps;..\..\src\components\bal;..\..\src\components\lib_util;..\..\src\components\mcal\conf;..\..\src\components\mcal\driver\Inc;..\..\src\components\os;..\..\src\components\haddock-os;..\..\src\components\easylinkin;..\..\src\components\easylinkin\lpwan_mac;..\..\src\components\easylinkin\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group apps
    ../../src/apps/: app_config.c app_config.h app_hostif.c app_hostif.h simple_log.c simple_log.h
  group components/bal
    ../../src/components/bal/: bal_cfg.h bal_lora_settings.c bal_lora_settings.h
  group components/bal/sx1278
    ../../src/components/bal/sx1278/: sx1276_config.h sx1278_cfg.h sx1278_spi.c sx1278_spi.h sx1278.c sx1278_reg.h sx1278_dio.c sx1278_dio.h rf_manager.c rf_manager.h
  group components/bal/uart
    ../../src/components/bal/uart/: uart.c uart.h
  group components/lib_util
    ../../src/components/lib_util/crc/: crc.c crc.h
    ../../src/components/lib_util/: cfifo.h
  group components/mcal/conf
    ../../src/components/mcal/conf/: stm32l0xx_hal_conf.h stm32l0xx_hal_msp.c stm32l0xx_it.c stm32l0xx_it.h system_stm32l0xx.c
  group components/mcal/driver
    ../../src/components/mcal/driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group components/mcal/mdk_arm
    ../../src/components/mcal/mdk_arm/: startup_stm32l051xx.s
  group components/notes/codesamples
    ../../src/components/notes/codesamples/: c_template.txt h_template.txt
  group components/easylinkin/radio
    ../../src/components/easylinkin/radio/: lpwan_radio.c lpwan_radio.h radio_config.h
  group components/easylinkin/llpwan_mac
    ../../src/components/easylinkin/lpwan_mac/: lpwan_config.c lpwan_config.h lpwan_types.h lpwan_utils.c lpwan_utils.h
  group components/easylinkin/llpwan_mac/end_device
    ../../src/components/easylinkin/lpwan_mac/end_device/: config_end_device.h mac_engine.c mac_engine.h mac_engine_config.h
  group components/easylinkin/llpwan_mac/frame_defs
    ../../src/components/easylinkin/lpwan_mac/frame_defs/: common_defs.h device_join_request.h device_uplink_ack.h device_uplink_cmd.h device_uplink_common.h device_uplink_data_request.h device_uplink_msg.h frame_defs.h frame_header.h gw_beacon.h gw_downlink_ack.h gw_downlink_cmd.h gw_downlink_common.h gw_downlink_msg.h gw_join_response.h gw_beacon.c
  group components/easylinkin/llpwan_mac/gateway
    ../../src/components/easylinkin/lpwan_mac/gateway/: config_gateway.h mac_engine.c mac_engine.h mac_engine_driver.c mac_engine_driver.h
  group components/easylinkin/llpwan_mac/protocol_utils
    ../../src/components/easylinkin/lpwan_mac/protocol_utils/: construct_de_uplink_msg.c construct_de_uplink_msg.h construct_frame_hdr.c construct_frame_hdr.h construct_gw_beacon.c construct_gw_beacon.h parse_beacon.c parse_beacon.h parse_device_uplink_msg.c parse_device_uplink_msg.h parse_frame_hdr.c parse_frame_hdr.h parse_gw_join_response.c parse_gw_join_response.h parsed_common_defs.h construct_de_uplink_common.c construct_de_uplink_common.h
  group components/easylinkin/llpwan_mac/radio_controller
    ../../src/components/easylinkin/lpwan_mac/radio_controller/: radio_controller.c radio_controller.h
  group components/haddock-os
    ../../src/components/haddock-os/: haddock_types.h hdk_user_config.h
  group components/haddock-os/hal
    ../../src/components/haddock-os/hal/: hal_config.h hal_mcu.h
  group components/haddock-os/hal/stm32l051
    ../../src/components/haddock-os/hal/stm32l051/: hal_config_stm32l051.h hal_init.c hal_sleep.c hal_stm32l051.h systick.c systick.h
  group components/haddock-os/kernel
    ../../src/components/haddock-os/kernel/: hdk_memory.c hdk_memory.h ipc.c ipc.h kernel_config.c kernel_config.h kernel_main.c power_manager.c power_manager.h process.c process.h scheduler.c scheduler.h sys_signal_defs.h timer.c timer.h
  group components/haddock-os/lib
    ../../src/components/haddock-os/lib/: assert.c assert.h hdk_utilities.c hdk_utilities.h linked_list.h mem_pool.c mem_pool.h ringbuffer.c ringbuffer.h crc_generator.c crc_generator.h
  group components/haddock-os/os_user_processes
    ../../src/components/haddock-os/os_user_processes/: os_user_processes.h
  group components/haddock-os/os_user_processes/easylinkin_modem
    ../../src/components/haddock-os/os_user_processes/easylinkin_modem/: easylinkin_modem_process.c easylinkin_modem_process.h process_hostif.c process_hostif.h process_test_end_device_app.c process_test_end_device_app.h
  group components/external_comm_protocol
    ../../src/components/external_comm_protocol/: ecp_gw_modem.c ecp_gw_modem.h ecp_sn_modem.c ecp_sn_modem.h
  group components/easylinkin/llpwan_mac/end_device/beacon_tracker
    ../../src/components/easylinkin/lpwan_mac/end_device/beacon_tracker/: beacon_tracker.c beacon_tracker.h
  group components/easylinkin/llpwan_mac/end_device/tx_frames_mgmt
    ../../src/components/easylinkin/lpwan_mac/end_device/tx_frames_mgmt/: tx_frames_mgmt.c tx_frames_mgmt.h
